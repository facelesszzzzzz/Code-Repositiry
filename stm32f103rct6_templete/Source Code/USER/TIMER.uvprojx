# Keil uVision project TIMER.uvprojx, settings and files
target stm32f103_APP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIMER +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ESP8266;..\HARDWARE\BODY;..\HARDWARE\RC522;..\HARDWARE\BEEP;..\HARDWARE\OLED;..\SYSTEM\datatype;..\HARDWARE\DHT22;..\HARDWARE\ADC;..\HARDWARE\MQ2;..\HARDWARE\RELAY;..\SYSTEM\warning;..\BSP\inc;..\..\..\..\第二波\2021 03 17 老人健康监护系统\代码调试\stm32f103rct6\Source Code\HARDWARE\MAX30102
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c run.c glob.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c
  group BSP
    ../BSP/src/: bsp_gpio.c bsp.c bsp_uart.c bsp_interrupt.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c usart3.c usart2.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c
  group README
    ../: README.TXT
